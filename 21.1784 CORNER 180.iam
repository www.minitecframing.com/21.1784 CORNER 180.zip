# Autodesk Inventor assembly: 21.1784 CORNER 180
## iProperties
Created: 2007-04
Part Number: 21.1784 CORNER 180
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
